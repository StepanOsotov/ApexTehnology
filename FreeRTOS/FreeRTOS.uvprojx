# Keil uVision project FreeRTOS.uvprojx, settings and files
target rtosL152 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L152RCTx STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L1XX_MD
  c include: .\usr_libs\CMSIS;.\usr_libs\Conf;.\usr_libs\Drivers\inc;.\usr_libs\Interrupt;.\usr_libs\StartUp;.\usr_rtos\include;.\usr_src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group startup
    ./usr_libs/StartUp/: core_cm3.c startup_stm32l152xc.s
  group cmsis
    ./usr_libs/CMSIS/: system_stm32l1xx.c
  group drivers
    ./usr_libs/Drivers/src/: misc.c stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_wwdg.c
  group usersrc
    ./usr_src/: delay_us.c init_periph.c main.c user_tasks.c usart3_usr.c usart2_usr.c
  group rtos
    ./usr_rtos/: croutine.c event_groups.c heap_4.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
  group it
    ./usr_libs/Interrupt/: stm32l1xx_it.c
